# Keil uVision project Template.uvprojx, settings and files
target Template (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ELITTLE
  output: robocup_m10p +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,__CC_ARM,ARM_MATH_CM4
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\HARDWARE\DMA;..\HARDWARE\hc-05;..\HARDWARE\LEIDA_DATA;..\HARDWARE\DSP;..\HARDWARE\CENTRE_LINE;..\HARDWARE\LEIDA_TIMER;..\HARDWARE\moto;..\HARDWARE\Servo;..\HARDWARE\TIM\PWM;..\test
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\m10p.sct
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma2d.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group README
    ../: readme.txt
  group HARDWARE
    ../HARDWARE/DMA/: DMA.c DMA.h
    ../HARDWARE/hc-05/: bsp_bluetooth.c bsp_bluetooth.h ble_diag.c ble_diag.h ble_tx.c ble_tune.c ble_tune.h
    ../HARDWARE/LEIDA_DATA/: LEIDA_DATA.c LEIDA_DATA.h
    ../HARDWARE/DSP/: arm_cortexM4lf_math.lib arm_math.h
    ../HARDWARE/CENTRE_LINE/: CENTRE_LINE.c path_track.c
    ../HARDWARE/LEIDA_TIMER/: timer.c
    ../HARDWARE/moto/: moto.c
    ../HARDWARE/Servo/: Servo.c
    ../HARDWARE/TIM/PWM/: PWM.c
  group test
    ../test/: test.h test_servo.c test_motor.c test_bluetooth.c
  group M10P
    ../HARDWARE/LEIDA_DATA/: m10p.c m10p_vehicle.c
